	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN

	AREA mycode, CODE, READONLY
ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =VALUE1
	LDR R1, [R0]

	LDR R0, =VALUE2
	LDR R2, [R0]

	MOV R3, #0

	CMP R2, #0
	BEQ DIV_ZERO

DIV_LOOP
	CMP R1, R2
	BLT END_DIV

	SUB R1, R1, R2
	ADD R3, R3, #1
	B DIV_LOOP

END_DIV
	LDR R0, =RESULT
	STR R3, [R0]

STOP
	B STOP

DIV_ZERO
	LDR R0, =RESULT
	MOV R3, #0
	STR R3, [R0]
	B STOP

VALUE1 DCD 0x00000012
VALUE2 DCD 0x00000005

	AREA data, DATA, READWRITE
RESULT DCD 0

	END
